DESCRIPTION = "PJRX minimal Raspberry Pi 5 image"
LICENSE = "MIT"

inherit core-image



